#
# CIP Core, generic profile
#
# Copyright (c) Siemens AG, 2019-2026
#
# Authors:
#  Jan Kiszka <jan.kiszka@siemens.com>
#
# SPDX-License-Identifier: MIT
#

require linux-cip-release.inc

SRC_URI[sha256sum] = "aac5292feb94163f9c97a2886fdb0e58e84f1be87ea787b9fc858e0b17c9529b"
