#
# CIP Core, generic profile
#
# Copyright (c) Siemens AG, 2026
#
# SPDX-License-Identifier: MIT

require linux-cip-release.inc

SRC_URI[sha256sum] = "404a492ac47b321f2657e1345821e9aac16bb07f8d8703ca1774f59016fa6c3c"
