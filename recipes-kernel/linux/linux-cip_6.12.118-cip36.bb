#
# CIP Core, generic profile
#
# Copyright (c) Siemens AG, 2026
#
# SPDX-License-Identifier: MIT

require linux-cip-release.inc

SRC_URI[sha256sum] = "44f217dad9f40bf17cbcda7e5ef62940ce05f35347e036a65b90a8094c76f4bc"
