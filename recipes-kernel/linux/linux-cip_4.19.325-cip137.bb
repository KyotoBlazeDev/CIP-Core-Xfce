#
# CIP Core, generic profile
#
# Copyright (c) Siemens AG, 2019-2023
#
# Authors:
#  Jan Kiszka <jan.kiszka@siemens.com>
#
# SPDX-License-Identifier: MIT
#

require linux-cip-release.inc

SRC_URI[sha256sum] = "0788097dc70bea3fb512e6f6d6401d21bd54f4d3779c0d0190c62aeb599564d6"
